Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition[CoordinationView_V2.0], ExchangeRequirement[Structural, SurfaceGeometry], Option [GridExport:Off], Option [Assemblies:On], Option [Bolts:Off], Option [Rebars:Off], Option [PourObjects:Off], Option [Welds:Off], Option [SurfaceTreatments:Off], Option [LocationBy:0], Option [ViewColors:Off], Option [SectionedSpine:Off], Option [PropertySets:On], Option [Export all:Off]
File name: POD-IFC.ifc
Time: 2026-09-17T12:15:54
Author: DAMACHOLDING\Sherin.Worin
Organization: Structural Designer
Written by: IFC Parser Version: 3.14.0
Made in: Tekla Structures 2025 Service Pack 3, IFC Export Version: 4.0.0.0 Jun 9 2025

# IfcBuildingStorey, Undefined
In: Undefined
Elevation: 0 mm

# IfcBeam: PL4*60 (6)
In: Undefined
Description: PL4*60; Material: STEEL/S275
Tekla Common - Class: 99; Phase: 101; Top elevation: +0.123; Bottom elevation: +0.003
Tekla Quantity - Length: 120 mm; Width: 4 mm; Height: 60 mm; Net surface area: 0.016 m2; Area per tons: 70.064 m2; Gross footprint area: 0 m2; Volume: 0 m3; Weight: 0.23 kg
BeamBaseQuantities - Length: 120 mm; OuterSurfaceArea: 0 m2; NetVolume: 0 m3; NetWeight: 0.2 kg
Pset_BeamCommon - Slope: 1.5708 rad

# IfcBeam: RHS120*60*4.0 (10)
In: Undefined
Description: RHS120*60*4.0; Material: STEEL/S275
Tekla Common - Class: 3; Phase: 101; Top elevation: +0.123; Bottom elevation: +0.003
Tekla Quantity - Width: 60 mm; Height: 120 mm; Area per tons: 32.784 m2
BeamBaseQuantities - NetVolume: 0 m3
Pset_BeamCommon - Slope: 0 rad
Name | Tekla Quantity, Length (mm) = BeamBaseQuantities, Length (mm) | Net surface area (m2) | Gross footprint area (m2) | Volume (m3) | Weight (kg) | OuterSurfaceArea (m2) | NetWeight (kg)
BASE_FRAME | 2199 | 0.784 | 0.132 | 0.003 | 23.48 | 0.8 | 23.8
BASE_FRAME | 181 | 0.066 | 0.011 | 0 | 1.93 | 0.1 | 2
BASE_FRAME | 3159 | 1.126 | 0.19 | 0.004 | 33.73 | 1.1 | 34.1
BASE_FRAME | 613 | 0.22 | 0.037 | 0.001 | 6.54 | 0.2 | 6.6
2 x BASE_FRAME | 622 | 0.223 | 0.037 | 0.001 | 6.64 | 0.2 | 6.6
BASE_FRAME | 1556 | 0.555 | 0.093 | 0.002 | 16.61 | 0.5 | 16.8
BASE_FRAME | 713 | 0.255 | 0.043 | 0.001 | 7.61 | 0.2 | 7.7
BASE_FRAME | 63 | 0.024 | 0.004 | 0 | 0.67 | 0 | 0.7
BASE_FRAME | 3032 | 1.08 | 0.182 | 0.004 | 32.37 | 1.1 | 32.8

# IfcBeam: RHS40*20*3 (7)
In: Undefined
Description: RHS40*20*3; Material: STEEL/S275
Tekla Common - Class: 11; Phase: 101; Top elevation: +0.023; Bottom elevation: +0.003
Tekla Quantity - Width: 20 mm; Height: 40 mm; Volume: 0 m3
BeamBaseQuantities - NetVolume: 0 m3
Pset_BeamCommon - Slope: 0 rad
Name | Tekla Quantity, Length (mm) = BeamBaseQuantities, Length (mm) | Net surface area (m2) | Area per tons (m2) | Gross footprint area (m2) | Weight (kg) | OuterSurfaceArea (m2) | NetWeight (kg)
2 x FRAME | 122 | 0.012 | 47.536 | 0.004 | 0.26 | 0 | 0.3
FRAME | 598.1 | 0.068 | 46.193 | 0.023 | 1.47 | 0.1 | 1.5
FRAME | 1509.5 | 0.177 | 45.997 | 0.06 | 3.84 | 0.2 | 3.8
FRAME | 596.4 | 0.068 | 46.194 | 0.023 | 1.47 | 0.1 | 1.5
FRAME | 212 | 0.023 | 46.772 | 0.008 | 0.49 | 0 | 0.5
FRAME | 833.5 | 0.095 | 46.11 | 0.033 | 2.07 | 0.1 | 2.1

# IfcBeam: RHS60*30*4 (2)
In: Undefined
Description: RHS60*30*4; Material: STEEL/S275
Tekla Common - Class: 4; Phase: 101; Top elevation: +0.033; Bottom elevation: +0.003
Tekla Quantity - Width: 30 mm; Height: 60 mm; Volume: 0.001 m3
BeamBaseQuantities - OuterSurfaceArea: 0.2 m2; NetVolume: 0 m3
Pset_BeamCommon - Slope: 0 rad
Name | Tekla Quantity, Length (mm) = BeamBaseQuantities, Length (mm) | Net surface area (m2) | Area per tons (m2) | Gross footprint area (m2) | Weight (kg) | NetWeight (kg)
FRAME | 956 | 0.169 | 34.265 | 0.057 | 4.92 | 4.9
FRAME | 906 | 0.16 | 34.273 | 0.054 | 4.67 | 4.7

# IfcElementAssembly, BASE_FRAME
In: Undefined
Tekla Assembly - Assembly/Cast unit Mark: BP3-BF1; Assembly/Cast unit position code: -/; Assembly/Cast unit top elevation: +0.123; Assembly/Cast unit bottom elevation: +0.003; Assembly/Cast unit weight: 157 kg
AssemblyBaseQuantities - Width: 3219 mm
